Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-05-08T07:52:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 08 07:52:50 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{F9262BF0-98EC-413A-B4F7-FFA8C617CCC1}\ifc * Database version: 5507 * Database creation date: Wed May 08 07:52:49 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 08 07:52:50 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 08 07:52:50 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 21710016_OE1_11109710_G7100SC_BW, 11109710_OE1_G7100SC_BW:21710016_OE1_11109710_G7100SC_BW:207988
In: Level 1
Type - Classification: G7000 (Uniformat); Material: z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, Polypropylene, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 21710016_OE1_11109710_G7100SC_BW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
